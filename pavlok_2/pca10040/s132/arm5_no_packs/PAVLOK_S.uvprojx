# Keil uVision project PAVLOK_S.uvprojx, settings and files
target PAVLOK_2 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.12.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: Pavlok_HW_Test +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: NRF52 NRF52832_XXAA  BOARD_PCA10040 CONFIG_NFCT_PINS_AS_GPIOS  CONFIG_GPIO_AS_PINRESET FREERTOS NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 NRF52_PAN_74 NRF_SD_BLE_API_VERSION=4 S132  __HEAP_SIZE=2048 __STACK_SIZE=4096 NRF_LOG_ENABLED NRF_LOG_USES_RTT=1 PAVLOK_CFG_ENABLED PAVLOK_NOTIFY_ENABLED PAVLOK_SOL_ENABLED PAVLOK_TRAIN_ENABLED PAVLOK_APPSVC_ENABLED PAVLOK_LOG_ENABLED PAVLOK_OTA_ENABLED INCLUDE_SVC_TASK INCLUDE_APP_TASK INCLUDE_HABIT_TASK  INCLUDE_LOGGER_TASK
  c misc: --reduce_paths
  c include: ..\..\..\Pavlok_System;..\..\..\Pavlok_Bsp;..\..\..\..\nRF5_SDK_13_NEW\components;..\..\..\..\nRF5_SDK_13_NEW\components\ble\ble_advertising;..\..\..\..\nRF5_SDK_13_NEW\components\ble\ble_dtm;..\..\..\..\nRF5_SDK_13_NEW\components\ble\ble_services\ble_dfu;..\..\..\..\nRF5_SDK_13_NEW\components\ble\ble_services\ble_hrs;..\..\..\..\nRF5_SDK_13_NEW\components\ble\ble_services\ble_hrs_c;..\..\..\..\nRF5_SDK_13_NEW\components\ble\common;..\..\..\..\nRF5_SDK_13_NEW\components\ble\nrf_ble_gatt;..\..\..\..\nRF5_SDK_13_NEW\components\ble\nrf_ble_qwr;..\..\..\..\nRF5_SDK_13_NEW\components\ble\peer_manager;..\..\..\..\nRF5_SDK_13_NEW\components\boards;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\clock;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\common;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\comp;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\delay;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\gpiote;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\hal;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\i2s;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\lpcomp;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\pdm;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\power;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\ppi;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\pwm;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\qdec;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\rng;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\rtc;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\saadc;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\spi_master;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\spi_slave;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\swi;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\timer;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\twi_master;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\twis_slave;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\uart;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\wdt;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\bsp;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\button;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\crc16;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\crc32;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\csense;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\csense_drv;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\ecc;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\experimental_section_vars;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\fds;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\fstorage;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\gpiote;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\hardfault;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\hci;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\log;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\log\src;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\low_power_pwm;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\mem_manager;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\pwm;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\queue;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\scheduler;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\sensorsim;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\slip;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\strerror;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\timer;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\twi;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\uart;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\util;..\..\..\..\nRF5_SDK_13_NEW\components\softdevice\common\softdevice_handler;..\..\..\..\nRF5_SDK_13_NEW\components\softdevice\s132\headers;..\..\..\..\nRF5_SDK_13_NEW\components\softdevice\s132\headers\nrf52;..\..\..\..\nRF5_SDK_13_NEW\components\toolchain;..\..\..\..\nRF5_SDK_13_NEW\external\freertos\config;..\..\..\..\nRF5_SDK_13_NEW\external\freertos\portable\ARM\nrf52;..\..\..\..\nRF5_SDK_13_NEW\external\freertos\portable\CMSIS\nrf52;..\..\..\..\nRF5_SDK_13_NEW\external\freertos\source\include;..\..\..\..\nRF5_SDK_13_NEW\external\segger_rtt;..\..\..\Pavlok_Drivers;..\..\..\Pavlok_Services;..\..\..\Pavlok_Application;C:\Keil_v5\ARM\Pack\NordicSemiconductor\RTT
  asm define: BLE_STACK_SUPPORT_REQD BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FREERTOS NRF52 NRF52832_XXAA NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 NRF52_PAN_74 NRF_SD_BLE_API_VERSION=4 S132 SOFTDEVICE_PRESENT __HEAP_SIZE=1024 __STACK_SIZE=2048
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFREERTOS,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_64,-DNRF52_PAN_74,-DNRF_SD_BLE_API_VERSION=4,-DS132,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=1024,-D__STACK_SIZE=2048
  asm include: ..\..\..\config;..\..\..\..\nRF5_SDK_13_NEW\components;..\..\..\..\nRF5_SDK_13_NEW\components\ble\ble_advertising;..\..\..\..\nRF5_SDK_13_NEW\components\ble\ble_dtm;..\..\..\..\nRF5_SDK_13_NEW\components\ble\ble_racp;..\..\..\..\nRF5_SDK_13_NEW\components\ble\ble_services\ble_ancs_c;..\..\..\..\nRF5_SDK_13_NEW\components\ble\ble_services\ble_ans_c;..\..\..\..\nRF5_SDK_13_NEW\components\ble\ble_services\ble_bas;..\..\..\..\nRF5_SDK_13_NEW\components\ble\ble_services\ble_bas_c;..\..\..\..\nRF5_SDK_13_NEW\components\ble\ble_services\ble_cscs;..\..\..\..\nRF5_SDK_13_NEW\components\ble\ble_services\ble_cts_c;..\..\..\..\nRF5_SDK_13_NEW\components\ble\ble_services\ble_dfu;..\..\..\..\nRF5_SDK_13_NEW\components\ble\ble_services\ble_dis;..\..\..\..\nRF5_SDK_13_NEW\components\ble\ble_services\ble_gls;..\..\..\..\nRF5_SDK_13_NEW\components\ble\ble_services\ble_hids;..\..\..\..\nRF5_SDK_13_NEW\components\ble\ble_services\ble_hrs;..\..\..\..\nRF5_SDK_13_NEW\components\ble\ble_services\ble_hrs_c;..\..\..\..\nRF5_SDK_13_NEW\components\ble\ble_services\ble_hts;..\..\..\..\nRF5_SDK_13_NEW\components\ble\ble_services\ble_ias;..\..\..\..\nRF5_SDK_13_NEW\components\ble\ble_services\ble_ias_c;..\..\..\..\nRF5_SDK_13_NEW\components\ble\ble_services\ble_lbs;..\..\..\..\nRF5_SDK_13_NEW\components\ble\ble_services\ble_lbs_c;..\..\..\..\nRF5_SDK_13_NEW\components\ble\ble_services\ble_lls;..\..\..\..\nRF5_SDK_13_NEW\components\ble\ble_services\ble_nus;..\..\..\..\nRF5_SDK_13_NEW\components\ble\ble_services\ble_nus_c;..\..\..\..\nRF5_SDK_13_NEW\components\ble\ble_services\ble_rscs;..\..\..\..\nRF5_SDK_13_NEW\components\ble\ble_services\ble_rscs_c;..\..\..\..\nRF5_SDK_13_NEW\components\ble\ble_services\ble_tps;..\..\..\..\nRF5_SDK_13_NEW\components\ble\common;..\..\..\..\nRF5_SDK_13_NEW\components\ble\nrf_ble_gatt;..\..\..\..\nRF5_SDK_13_NEW\components\ble\nrf_ble_qwr;..\..\..\..\nRF5_SDK_13_NEW\components\ble\peer_manager;..\..\..\..\nRF5_SDK_13_NEW\components\boards;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\clock;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\common;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\comp;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\delay;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\gpiote;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\hal;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\i2s;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\lpcomp;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\pdm;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\power;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\ppi;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\pwm;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\qdec;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\rng;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\rtc;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\saadc;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\spi_master;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\spi_slave;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\swi;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\timer;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\twi_master;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\twis_slave;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\uart;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\usbd;..\..\..\..\nRF5_SDK_13_NEW\components\drivers_nrf\wdt;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\bsp;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\button;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\crc16;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\crc32;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\csense;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\csense_drv;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\ecc;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\experimental_section_vars;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\fds;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\fstorage;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\gpiote;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\hardfault;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\hci;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\led_softblink;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\log;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\log\src;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\low_power_pwm;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\mem_manager;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\pwm;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\queue;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\scheduler;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\sensorsim;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\slip;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\strerror;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\timer;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\twi;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\uart;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\usbd;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\usbd\class\audio;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\usbd\class\cdc;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\usbd\class\cdc\acm;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\usbd\class\hid;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\usbd\class\hid\generic;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\usbd\class\hid\kbd;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\usbd\class\hid\mouse;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\usbd\class\msc;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\usbd\config;..\..\..\..\nRF5_SDK_13_NEW\components\libraries\util;..\..\..\..\nRF5_SDK_13_NEW\components\softdevice\common\softdevice_handler;..\..\..\..\nRF5_SDK_13_NEW\components\softdevice\s132\headers;..\..\..\..\nRF5_SDK_13_NEW\components\softdevice\s132\headers\nrf52;..\..\..\..\nRF5_SDK_13_NEW\components\toolchain;..\..\..\..\nRF5_SDK_13_NEW\external\freertos\config;..\..\..\..\nRF5_SDK_13_NEW\external\freertos\portable\ARM\nrf52;..\..\..\..\nRF5_SDK_13_NEW\external\freertos\portable\CMSIS\nrf52;..\..\..\..\nRF5_SDK_13_NEW\external\freertos\source\include;..\..\..\..\nRF5_SDK_13_NEW\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress 6330
  group Board Definition
    ../../../../nRF5_SDK_13_NEW/components/boards/: boards.c
  group Third Parties
    ../../../../nRF5_SDK_13_NEW/external/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../nRF5_SDK_13_NEW/external/freertos/portable/ARM/nrf52/: port.c
    ../../../../nRF5_SDK_13_NEW/external/freertos/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
    ../../../../nRF5_SDK_13_NEW/external/freertos/source/portable/MemMang/: heap_4.c
  group nRF_BLE
    ../../../../nRF5_SDK_13_NEW/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../../nRF5_SDK_13_NEW/components/ble/ble_advertising/: ble_advertising.c
    ../../../../nRF5_SDK_13_NEW/components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
    ../../../../nRF5_SDK_13_NEW/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
  group nRF_Drivers
    ../../../../nRF5_SDK_13_NEW/components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../nRF5_SDK_13_NEW/components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../nRF5_SDK_13_NEW/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../nRF5_SDK_13_NEW/components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../nRF5_SDK_13_NEW/components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../../../../nRF5_SDK_13_NEW/components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../../../../nRF5_SDK_13_NEW/components/drivers_nrf/saadc/: nrf_drv_saadc.c
    ../../../../nRF5_SDK_13_NEW/components/drivers_nrf/timer/: nrf_drv_timer.c
    ../../../../nRF5_SDK_13_NEW/components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../../../../nRF5_SDK_13_NEW/components/drivers_nrf/pwm/: nrf_drv_pwm.c
    ../../../../nRF5_SDK_13_NEW/components/drivers_nrf/hal/: nrf_saadc.c
  group nRF_Libraries
    ../../../../nRF5_SDK_13_NEW/components/libraries/button/: app_button.c
    ../../../../nRF5_SDK_13_NEW/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_mapped_flags.c
    ../../../../nRF5_SDK_13_NEW/components/libraries/timer/: app_timer_freertos.c
    ../../../../nRF5_SDK_13_NEW/components/libraries/crc16/: crc16.c
    ../../../../nRF5_SDK_13_NEW/components/libraries/fds/: fds.c
    ../../../../nRF5_SDK_13_NEW/components/libraries/fstorage/: fstorage.c
    ../../../../nRF5_SDK_13_NEW/components/libraries/hardfault/: hardfault_implementation.c
    ../../../../nRF5_SDK_13_NEW/components/libraries/strerror/: nrf_strerror.c
    ../../../../nRF5_SDK_13_NEW/components/libraries/hardfault/nrf52/handler/: hardfault_handler_keil.c
    ../../../../nRF5_SDK_13_NEW/components/libraries/fifo/: app_fifo.c
    ../../../../nRF5_SDK_13_NEW/components/libraries/uart/: app_uart.c
    ../../../../nRF5_SDK_13_NEW/components/libraries/mem_manager/: mem_manager.c
  group nRF_Log
    ../../../../nRF5_SDK_13_NEW/components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ../../../../nRF5_SDK_13_NEW/external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../../nRF5_SDK_13_NEW/components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group Pavlok_System
    ../../../Pavlok_System/: FreeRTOSConfig.h pca10040.h sdk_config.h TODO.txt TEST_TODO.txt
  group Pavlok_Bsp
    ../../../Pavlok_BSP/: bsp.c
  group Pavlok_Application
    ../../../Pavlok_Application/: main.c
  group Pavlok_Drivers
    ../../../Pavlok_Drivers/: adc.c debug.c i2c.c leds.c pwm.c accel_mag.c rtc.c spi.c zap.c serial_flash.c gyro.c
target flash_s132_nrf52_4.0.2_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.12.0
  cpu: as above
  output: s132_nrf52_4.0.2_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c misc: --reduce_paths
  c include: ..\..\..\config;..\config
  asm misc: --cpreproc_opts=
  asm include: ..\..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x20001fc0 size 0xe040
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 5.0.1, CMSIS:CORE 4.3.0, Device:Startup 8.12.0
